# Keil uVision project vehicle.uvprojx, settings and files
target vehicle (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: vehicle +hex
  AfterMake: fromelf.exe --bin -o "$L@L.bin" "#L"
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB,APPLICATION_OFFSET=0X00000000
  c include: ..\..\..\Drivers\CMSIS\Include;..\..\..\Drivers\CMSIS\Device\ST\STM32F1xx\Include;..\..\..\Drivers\STM32F1xx_HAL_Driver\Inc;..\..\..\Drivers\STM32F1xx_HAL_Driver\Inc\Legacy;..\Core\Inc;..\Modules\inc;..\..\..\Utilities\CPU_ID;..\..\..\Utilities\CRC16;..\..\..\Utilities\XXTEA
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x1000
  link misc: --diag_suppress=L6329
  group Drivers/CMSIS
    ../../../Drivers/CMSIS/Device/ST/STM32F1xx/Source/Templates/: system_stm32f1xx.c
  group Drivers/CMSIS/Lib/ARM
    ../../../Drivers/CMSIS/Lib/ARM/: arm_cortexM3l_math.lib
  group Drivers/STM32F1xx_HAL_Driver
    ../../../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_can.c stm32f1xx_hal_cec.c stm32f1xx_hal_cortex.c stm32f1xx_hal_crc.c stm32f1xx_hal_dac.c stm32f1xx_hal_dac_ex.c stm32f1xx_hal_dma.c stm32f1xx_hal_eth.c stm32f1xx_hal_exti.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_hcd.c stm32f1xx_hal_i2c.c stm32f1xx_hal_i2s.c stm32f1xx_hal_irda.c stm32f1xx_hal_iwdg.c stm32f1xx_hal_mmc.c stm32f1xx_hal_nand.c stm32f1xx_hal_nor.c stm32f1xx_hal_pccard.c stm32f1xx_hal_pcd.c stm32f1xx_hal_pcd_ex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_rtc.c stm32f1xx_hal_rtc_ex.c stm32f1xx_hal_sd.c stm32f1xx_hal_smartcard.c stm32f1xx_hal_spi.c stm32f1xx_hal_sram.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_usart.c stm32f1xx_hal_wwdg.c stm32f1xx_ll_adc.c stm32f1xx_ll_crc.c stm32f1xx_ll_dac.c stm32f1xx_ll_dma.c stm32f1xx_ll_exti.c stm32f1xx_ll_fsmc.c stm32f1xx_ll_gpio.c stm32f1xx_ll_i2c.c stm32f1xx_ll_pwr.c stm32f1xx_ll_rcc.c stm32f1xx_ll_rtc.c stm32f1xx_ll_sdmmc.c stm32f1xx_ll_spi.c stm32f1xx_ll_tim.c stm32f1xx_ll_usart.c stm32f1xx_ll_usb.c stm32f1xx_ll_utils.c
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/Core
    ../Core/Src/: main.c stm32f1xx_hal_msp.c stm32f1xx_it.c
  group Application/Modules
    ../Modules/src/: application.c common.c flash_if.c ymodem.c bsp.c bsp_sysKey.c bsp_sysLed.c bsp_uart1.c
  group Application/Readme
    ../Readme/: readme.txt
  group Utilities/CPU_ID
    ../../../Utilities/CPU_ID/: cpu_id.c
  group Utilities/XXTEA
    ../../../Utilities/XXTEA/: xxtea.c
  group Utilities/CRC16
    ../../../Utilities/CRC16/: crc16.c
software components: CMSIS:CORE 4.3.0
